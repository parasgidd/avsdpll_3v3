*final PLL101 from layout

* SPICE3 file created from pfd_cp101.ext - technology: scmos

.include osu018.lib

.option scale=0.1u

M1000 a_264_214# dn a_257_230# w_251_224# pfet w=8 l=2
+  ad=80 pd=52 as=40 ps=26
M1001 a_102_19# a_78_19# gnd gnd nfet w=3 l=2
+  ad=23 pd=20 as=1404 ps=998
M1002 vdd a_48_36# a_43_86# vdd pfet w=11 l=2
+  ad=3137 pd=1652 as=88 ps=38
M1003 a_127_406# a_102_336# gnd gnd nfet w=9 l=2
+  ad=81 pd=36 as=0 ps=0
M1004 a_66_299# a_43_336# vdd vdd pfet w=11 l=2
+  ad=88 pd=38 as=0 ps=0
M1005 vdd a_23_n117# fvco_8 vdd pfet w=8 l=2
+  ad=0 pd=0 as=56 ps=30
M1006 a_186_n117# a_205_n101# a_159_n115# gnd nfet w=3 l=2
+  ad=46 pd=34 as=86 ps=64
M1007 vdd vdd gnd gnd nfet w=3 l=2
+  ad=3473 pd=2920 as=0 ps=0
M1008 vdd a_205_n72# a_322_n115# vdd pfet w=8 l=2
+  ad=0 pd=0 as=176 ps=76
M1009 a_186_n117# a_205_n72# a_159_n115# vdd pfet w=8 l=2
+  ad=96 pd=40 as=176 ps=76
M1010 a_135_228# a_66_299# gnd gnd nfet w=13 l=2
+  ad=52 pd=34 as=0 ps=0
M1011 a_66_123# a_43_86# vdd vdd pfet w=11 l=2
+  ad=88 pd=38 as=0 ps=0
M1012 a_55_n117# a_42_n101# a_23_n117# vdd pfet w=8 l=2
+  ad=88 pd=38 as=96 ps=40
M1013 a_264_251# up vdd w_251_224# pfet w=8 l=2
+  ad=80 pd=52 as=0 ps=0
M1015 a_208_n115# a_205_n101# a_198_n115# vdd pfet w=8 l=2
+  ad=80 pd=36 as=112 ps=60
M1016 gnd cp a_548_n53# gnd nfet w=3 l=2
+  ad=0 pd=0 as=9 ps=12
M1017 a_102_336# a_78_336# gnd gnd nfet w=3 l=2
+  ad=23 pd=20 as=0 ps=0
M1018 a_74_227# a_110_121# a_102_229# gnd nfet w=6 l=2
+  ad=36 pd=24 as=48 ps=28
M1019 vdd a_361_n115# a_381_n117# vdd pfet w=8 l=2
+  ad=0 pd=0 as=88 ps=38
M1020 vdd a_349_n117# a_205_n72# vdd pfet w=8 l=2
+  ad=0 pd=0 as=56 ps=30
M1021 a_548_n53# a_546_n95# a_529_n95# gnd nfet w=3 l=2
+  ad=0 pd=0 as=23 ps=20
M1022 a_43_336# a_18_336# vdd vdd pfet w=11 l=2
+  ad=88 pd=38 as=0 ps=0
M1023 vdd a_42_n72# a_42_n101# vdd pfet w=8 l=2
+  ad=0 pd=0 as=56 ps=30
M1024 a_632_n93# a_529_n95# a_609_n95# vdd pfet w=6 l=2
+  ad=18 pd=18 as=30 ps=22
M1025 gnd a_381_n117# a_371_n115# gnd nfet w=3 l=2
+  ad=0 pd=0 as=40 ps=30
M1026 a_110_121# a_43_336# vdd vdd pfet w=11 l=2
+  ad=198 pd=80 as=0 ps=0
M1027 a_280_214# vdd a_264_214# w_251_224# pfet w=8 l=2
+  ad=40 pd=26 as=0 ps=0
M1028 a_43_86# a_48_36# a_43_17# gnd nfet w=6 l=2
+  ad=36 pd=24 as=48 ps=28
M1029 dn a_48_36# vdd vdd pfet w=11 l=2
+  ad=55 pd=32 as=0 ps=0
M1030 a_18_336# fin gnd gnd nfet w=3 l=2
+  ad=23 pd=20 as=0 ps=0
M1031 a_66_299# a_74_227# a_66_229# gnd nfet w=6 l=2
+  ad=36 pd=24 as=48 ps=28
M1032 vdd a_186_n117# a_42_n72# vdd pfet w=8 l=2
+  ad=0 pd=0 as=56 ps=30
M1033 a_45_n115# a_42_n72# a_35_n115# gnd nfet w=3 l=2
+  ad=40 pd=30 as=62 ps=48
M1034 vdd a_218_n117# a_208_n115# vdd pfet w=8 l=2
+  ad=0 pd=0 as=0 ps=0
M1035 vdd a_66_299# a_48_392# vdd pfet w=11 l=2
+  ad=0 pd=0 as=176 ps=76
M1036 a_280_251# vdd a_264_251# w_251_224# pfet w=8 l=2
+  ad=40 pd=26 as=0 ps=0
M1037 gnd cp a_569_n53# gnd nfet w=3 l=2
+  ad=0 pd=0 as=9 ps=12
M1038 up a_48_392# gnd gnd nfet w=3 l=2
+  ad=23 pd=20 as=0 ps=0
M1039 a_147_228# a_43_336# a_141_228# gnd nfet w=13 l=2
+  ad=52 pd=34 as=52 ps=34
M1040 cp vdd a_290_206# gnd nfet w=3 l=2
+  ad=23 pd=20 as=193 ps=92
M1041 a_569_n53# a_567_n95# a_546_n95# gnd nfet w=3 l=2
+  ad=0 pd=0 as=23 ps=20
M1042 a_43_86# a_18_19# vdd vdd pfet w=11 l=2
+  ad=0 pd=0 as=0 ps=0
M1043 a_110_121# a_66_299# vdd vdd pfet w=11 l=2
+  ad=0 pd=0 as=0 ps=0
M1044 gnd cp a_611_n53# gnd nfet w=3 l=2
+  ad=0 pd=0 as=9 ps=12

***********         Charge pump power transisters        *****************

M1014 a_289_251# a_280_251# vdd w_251_224# pfet w=6 l=2
+  ad=342 pd=150 as=0 ps=0
M1045 a_290_206# dn gnd gnd nfet w=3 l=2
+  ad=0 pd=0 as=0 ps=0

***************************************************************************

M1046 vdd a_551_n95# a_551_n95# vdd pfet w=6 l=2
+  ad=0 pd=0 as=30 ps=22
M1047 a_74_121# a_110_121# a_102_198# gnd nfet w=6 l=2
+  ad=36 pd=24 as=48 ps=28
M1048 a_611_n53# a_609_n95# a_588_n95# gnd nfet w=3 l=2
+  ad=0 pd=0 as=23 ps=20
M1049 gnd a_349_n117# a_205_n72# gnd nfet w=3 l=2
+  ad=0 pd=0 as=31 ps=24
M1050 a_n4_n115# a_42_n101# a_35_n115# gnd nfet w=3 l=2
+  ad=86 pd=64 as=0 ps=0
M1051 vdd fout a_368_n101# vdd pfet w=8 l=2
+  ad=0 pd=0 as=56 ps=30
M1052 a_159_n115# a_205_n72# a_198_n115# vdd pfet w=8 l=2
+  ad=0 pd=0 as=0 ps=0
M1053 gnd a_186_n117# a_42_n72# gnd nfet w=3 l=2
+  ad=0 pd=0 as=31 ps=24
M1054 a_78_19# a_43_86# vdd vdd pfet w=11 l=2
+  ad=55 pd=32 as=0 ps=0
M1055 a_78_336# a_43_336# gnd gnd nfet w=3 l=2
+  ad=23 pd=20 as=0 ps=0
M1056 a_66_123# a_74_121# a_66_198# gnd nfet w=6 l=2
+  ad=36 pd=24 as=48 ps=28
M1057 vdd a_529_n95# fout vdd pfet w=6 l=2
+  ad=0 pd=0 as=30 ps=22
M1058 gnd cp a_590_n53# gnd nfet w=3 l=2
+  ad=0 pd=0 as=9 ps=12
M1059 vdd a_42_n72# a_159_n115# vdd pfet w=8 l=2
+  ad=0 pd=0 as=0 ps=0
M1060 a_590_n53# a_588_n95# a_567_n95# gnd nfet w=3 l=2
+  ad=0 pd=0 as=23 ps=20
M1061 a_102_229# a_66_299# gnd gnd nfet w=6 l=2
+  ad=0 pd=0 as=0 ps=0
M1062 gnd a_55_n117# a_45_n115# gnd nfet w=3 l=2
+  ad=0 pd=0 as=0 ps=0
M1063 gnd cp a_632_n53# gnd nfet w=3 l=2
+  ad=0 pd=0 as=9 ps=12
M1064 a_43_17# a_18_19# gnd gnd nfet w=6 l=2
+  ad=0 pd=0 as=0 ps=0
M1065 a_102_19# a_78_19# vdd vdd pfet w=11 l=2
+  ad=55 pd=32 as=0 ps=0
M1066 a_138_406# a_66_299# a_127_406# gnd nfet w=9 l=2
+  ad=81 pd=36 as=0 ps=0
M1067 gnd a_35_n115# a_55_n117# gnd nfet w=3 l=2
+  ad=0 pd=0 as=43 ps=32
M1068 a_264_251# up gnd gnd nfet w=3 l=2
+  ad=46 pd=40 as=0 ps=0
M1069 vdd a_198_n115# a_218_n117# vdd pfet w=8 l=2
+  ad=0 pd=0 as=88 ps=38
M1070 a_18_19# fvco_8 gnd gnd nfet w=3 l=2
+  ad=23 pd=20 as=0 ps=0
M1071 a_23_n117# a_42_n101# a_n4_n115# gnd nfet w=3 l=2
+  ad=46 pd=34 as=0 ps=0
M1072 a_66_229# a_43_336# gnd gnd nfet w=6 l=2
+  ad=0 pd=0 as=0 ps=0
M1073 a_381_n117# a_368_n101# a_349_n117# vdd pfet w=8 l=2
+  ad=0 pd=0 as=96 ps=40
M1074 a_208_n115# a_205_n72# a_198_n115# gnd nfet w=3 l=2
+  ad=40 pd=30 as=62 ps=48
M1075 a_55_n117# a_42_n72# a_23_n117# gnd nfet w=3 l=2
+  ad=0 pd=0 as=0 ps=0
M1076 a_141_228# a_66_123# a_135_228# gnd nfet w=13 l=2
+  ad=0 pd=0 as=0 ps=0
M1077 gnd fvco_8 a_n4_n115# gnd nfet w=3 l=2
+  ad=0 pd=0 as=0 ps=0
M1078 a_48_36# a_110_121# a_138_18# gnd nfet w=9 l=2
+  ad=54 pd=30 as=81 ps=36
M1079 vdd a_381_n117# a_371_n115# vdd pfet w=8 l=2
+  ad=0 pd=0 as=80 ps=36
M1080 vdd a_551_n95# a_548_n93# vdd pfet w=6 l=2
+  ad=0 pd=0 as=18 ps=18
M1081 a_45_n115# a_42_n101# a_35_n115# vdd pfet w=8 l=2
+  ad=80 pd=36 as=112 ps=60
M1082 a_548_n93# a_546_n95# a_529_n95# vdd pfet w=6 l=2
+  ad=0 pd=0 as=30 ps=22
M1083 a_43_336# a_48_392# a_43_410# gnd nfet w=6 l=2
+  ad=36 pd=24 as=48 ps=28
M1084 a_102_198# a_66_123# gnd gnd nfet w=6 l=2
+  ad=0 pd=0 as=0 ps=0
M1085 gnd a_42_n72# a_42_n101# gnd nfet w=3 l=2
+  ad=0 pd=0 as=31 ps=24
M1086 vdd a_43_86# a_110_121# vdd pfet w=11 l=2
+  ad=0 pd=0 as=0 ps=0
M1087 a_159_n115# a_205_n101# a_198_n115# gnd nfet w=3 l=2
+  ad=0 pd=0 as=0 ps=0
M1088 a_138_18# a_66_123# a_127_18# gnd nfet w=9 l=2
+  ad=0 pd=0 as=81 ps=36
M1089 a_218_n117# a_205_n101# a_186_n117# vdd pfet w=8 l=2
+  ad=0 pd=0 as=0 ps=0
M1090 a_371_n115# a_368_n101# a_361_n115# vdd pfet w=8 l=2
+  ad=0 pd=0 as=112 ps=60
M1091 vdd a_110_121# a_74_227# vdd pfet w=11 l=2
+  ad=0 pd=0 as=88 ps=38
M1092 a_280_251# gnd a_264_251# gnd nfet w=3 l=2
+  ad=23 pd=20 as=0 ps=0
M1093 gnd a_198_n115# a_218_n117# gnd nfet w=3 l=2
+  ad=0 pd=0 as=43 ps=32
M1094 a_381_n117# fout a_349_n117# gnd nfet w=3 l=2
+  ad=43 pd=32 as=46 ps=34
M1095 a_48_36# a_110_121# vdd vdd pfet w=11 l=2
+  ad=176 pd=76 as=0 ps=0
M1096 a_102_336# a_78_336# vdd vdd pfet w=11 l=2
+  ad=55 pd=32 as=0 ps=0
M1097 a_289_251# up a_289_251# w_251_224# pfet w=8 l=2
+  ad=0 pd=0 as=0 ps=0
M1098 vdd a_110_121# a_74_121# vdd pfet w=11 l=2
+  ad=0 pd=0 as=88 ps=38
M1099 a_48_392# a_110_121# vdd vdd pfet w=11 l=2
+  ad=0 pd=0 as=0 ps=0
M1100 a_66_198# a_43_86# gnd gnd nfet w=6 l=2
+  ad=0 pd=0 as=0 ps=0
M1101 vdd a_551_n95# a_569_n93# vdd pfet w=6 l=2
+  ad=0 pd=0 as=18 ps=18
M1102 a_127_18# a_102_19# gnd gnd nfet w=9 l=2
+  ad=0 pd=0 as=0 ps=0
M1103 gnd a_218_n117# a_208_n115# gnd nfet w=3 l=2
+  ad=0 pd=0 as=0 ps=0
M1104 a_569_n93# a_567_n95# a_546_n95# vdd pfet w=6 l=2
+  ad=0 pd=0 as=30 ps=22
M1105 a_632_n53# a_529_n95# a_609_n95# gnd nfet w=3 l=2
+  ad=0 pd=0 as=23 ps=20
M1106 a_371_n115# fout a_361_n115# gnd nfet w=3 l=2
+  ad=0 pd=0 as=62 ps=48
M1107 gnd a_42_n72# a_159_n115# gnd nfet w=3 l=2
+  ad=0 pd=0 as=0 ps=0
M1108 a_264_214# dn gnd gnd nfet w=3 l=2
+  ad=46 pd=40 as=0 ps=0
M1109 vdd a_55_n117# a_45_n115# vdd pfet w=8 l=2
+  ad=0 pd=0 as=0 ps=0
M1110 a_218_n117# a_205_n72# a_186_n117# gnd nfet w=3 l=2
+  ad=0 pd=0 as=0 ps=0
M1111 vdd a_66_123# a_110_121# vdd pfet w=11 l=2
+  ad=0 pd=0 as=0 ps=0
M1112 vdd a_74_227# a_66_299# vdd pfet w=11 l=2
+  ad=0 pd=0 as=0 ps=0
M1113 vdd a_551_n95# a_611_n93# vdd pfet w=6 l=2
+  ad=0 pd=0 as=18 ps=18
M1114 dn a_48_36# gnd gnd nfet w=3 l=2
+  ad=23 pd=20 as=0 ps=0
M1115 vdd a_66_123# a_48_36# vdd pfet w=11 l=2
+  ad=0 pd=0 as=0 ps=0
M1116 a_18_336# fin vdd vdd pfet w=11 l=2
+  ad=55 pd=32 as=0 ps=0
M1117 a_611_n93# a_609_n95# a_588_n95# vdd pfet w=6 l=2
+  ad=0 pd=0 as=30 ps=22
M1118 vdd a_74_121# a_66_123# vdd pfet w=11 l=2
+  ad=0 pd=0 as=0 ps=0
M1119 cp gnd a_289_251# w_251_224# pfet w=8 l=2
+  ad=40 pd=26 as=0 ps=0
M1120 vdd a_205_n72# a_205_n101# vdd pfet w=8 l=2
+  ad=0 pd=0 as=56 ps=30
M1121 a_23_n117# a_42_n72# a_n4_n115# vdd pfet w=8 l=2
+  ad=0 pd=0 as=176 ps=76
M1122 a_48_392# a_102_336# vdd vdd pfet w=11 l=2
+  ad=0 pd=0 as=0 ps=0
M1123 a_322_n115# a_368_n101# a_361_n115# gnd nfet w=3 l=2
+  ad=86 pd=64 as=0 ps=0
M1124 gnd a_205_n72# a_205_n101# gnd nfet w=3 l=2
+  ad=0 pd=0 as=31 ps=24
M1125 up a_48_392# vdd vdd pfet w=11 l=2
+  ad=55 pd=32 as=0 ps=0
M1126 a_n4_n115# a_42_n72# a_35_n115# vdd pfet w=8 l=2
+  ad=0 pd=0 as=0 ps=0
M1127 a_48_36# a_102_19# vdd vdd pfet w=11 l=2
+  ad=0 pd=0 as=0 ps=0
M1128 vdd a_48_392# a_43_336# vdd pfet w=11 l=2
+  ad=0 pd=0 as=0 ps=0
M1129 vdd a_551_n95# a_590_n93# vdd pfet w=6 l=2
+  ad=0 pd=0 as=18 ps=18
M1130 gnd a_23_n117# fvco_8 gnd nfet w=3 l=2
+  ad=0 pd=0 as=31 ps=24
M1131 a_590_n93# a_588_n95# a_567_n95# vdd pfet w=6 l=2
+  ad=0 pd=0 as=30 ps=22
M1132 gnd cp a_551_n95# gnd nfet w=3 l=2
+  ad=0 pd=0 as=23 ps=20
M1133 gnd a_361_n115# a_381_n117# gnd nfet w=3 l=2
+  ad=0 pd=0 as=0 ps=0
M1134 a_43_410# a_18_336# gnd gnd nfet w=6 l=2
+  ad=0 pd=0 as=0 ps=0
M1135 a_280_214# gnd a_264_214# gnd nfet w=3 l=2
+  ad=23 pd=20 as=0 ps=0
M1136 vdd a_551_n95# a_632_n93# vdd pfet w=6 l=2
+  ad=0 pd=0 as=0 ps=0
M1137 vdd fvco_8 a_n4_n115# vdd pfet w=8 l=2
+  ad=0 pd=0 as=0 ps=0
M1138 a_48_392# a_110_121# a_138_406# gnd nfet w=9 l=2
+  ad=54 pd=30 as=0 ps=0
M1139 a_322_n115# fout a_361_n115# vdd pfet w=8 l=2
+  ad=0 pd=0 as=0 ps=0
M1140 gnd a_205_n72# a_322_n115# gnd nfet w=3 l=2
+  ad=0 pd=0 as=0 ps=0
M1141 a_18_19# fvco_8 vdd vdd pfet w=11 l=2
+  ad=55 pd=32 as=0 ps=0
M1142 vdd a_35_n115# a_55_n117# vdd pfet w=8 l=2
+  ad=0 pd=0 as=0 ps=0
M1143 gnd gnd vdd w_251_224# pfet w=7 l=2
+  ad=4683 pd=4118 as=0 ps=0
M1144 a_74_227# a_66_299# vdd vdd pfet w=11 l=2
+  ad=0 pd=0 as=0 ps=0
M1145 a_78_19# a_43_86# gnd gnd nfet w=3 l=2
+  ad=23 pd=20 as=0 ps=0
M1146 gnd a_529_n95# fout gnd nfet w=3 l=2
+  ad=0 pd=0 as=23 ps=20
M1147 a_78_336# a_43_336# vdd vdd pfet w=11 l=2
+  ad=55 pd=32 as=0 ps=0
M1148 a_349_n117# fout a_322_n115# vdd pfet w=8 l=2
+  ad=0 pd=0 as=0 ps=0
M1149 a_110_121# a_43_86# a_147_228# gnd nfet w=13 l=2
+  ad=130 pd=46 as=0 ps=0
M1150 a_74_121# a_66_123# vdd vdd pfet w=11 l=2
+  ad=0 pd=0 as=0 ps=0
M1151 a_349_n117# a_368_n101# a_322_n115# gnd nfet w=3 l=2
+  ad=0 pd=0 as=0 ps=0
M1152 a_290_206# a_280_214# a_290_206# gnd nfet w=3 l=2
+  ad=0 pd=0 as=0 ps=0
M1153 gnd fout a_368_n101# gnd nfet w=3 l=2
+  ad=0 pd=0 as=31 ps=24
C0 vdd a_361_n115# 0.38fF
C1 a_322_n115# a_349_n117# 0.02fF
C2 vdd a_48_392# 0.45fF
C3 cp a_551_n95# 0.13fF
C4 vdd a_567_n95# 0.19fF
C5 a_368_n101# a_371_n115# 0.08fF
C6 a_529_n95# fout 0.07fF
C7 vdd a_45_n115# 0.13fF
C8 a_48_392# a_66_299# 0.10fF
C9 a_567_n95# a_546_n95# 0.07fF
C10 vdd a_35_n115# 0.38fF
C11 a_159_n115# a_186_n117# 0.02fF
C12 vdd a_48_36# 0.45fF
C13 a_66_123# a_43_86# 0.01fF
C14 up a_264_251# 0.07fF
C15 vdd cp 0.05fF
C16 w_251_224# dn 0.07fF
C17 a_43_336# a_66_123# 0.25fF
C18 a_102_19# a_66_123# 0.03fF
C19 a_289_251# cp 0.07fF
C20 a_546_n95# cp 0.20fF
C21 a_n4_n115# a_23_n117# 0.02fF
C22 a_23_n117# fvco_8 0.07fF
C23 fvco_8 a_18_19# 0.05fF
C24 a_322_n115# a_361_n115# 0.06fF
C25 vdd fout 0.42fF
C26 vdd fin 0.07fF
C27 a_280_214# a_290_206# 0.07fF
C28 a_368_n101# a_381_n117# 0.22fF
C29 vdd a_55_n117# 0.13fF
C30 a_48_392# a_110_121# 0.10fF
C31 vdd up 0.22fF
C32 a_588_n95# a_529_n95# 0.04fF
C33 a_159_n115# a_198_n115# 0.06fF
C34 vdd a_42_n72# 0.58fF
C35 vdd a_78_19# 0.25fF
C36 up a_289_251# 0.04fF
C37 vdd a_257_230# 0.01fF
C38 w_251_224# cp 0.04fF
C39 a_588_n95# a_551_n95# 0.17fF
C40 a_43_336# a_43_86# 0.07fF
C41 a_n4_n115# a_45_n115# 0.02fF
C42 a_110_121# a_48_36# 0.10fF
C43 a_66_123# a_74_121# 0.17fF
C44 a_n4_n115# a_35_n115# 0.06fF
C45 a_349_n117# a_361_n115# 0.95fF
C46 a_18_336# a_48_392# 0.02fF
C47 a_322_n115# fout 0.14fF
C48 vdd a_371_n115# 0.13fF
C49 vdd a_588_n95# 0.19fF
C50 a_159_n115# a_218_n117# 0.02fF
C51 vdd a_42_n101# 0.37fF
C52 w_251_224# up 0.19fF
C53 vdd a_74_227# 0.27fF
C54 a_159_n115# a_205_n72# 0.14fF
C55 a_186_n117# a_198_n115# 0.95fF
C56 vdd m2_160_57# 0.09fF
C57 w_251_224# a_257_230# 0.02fF
C58 a_66_299# a_74_227# 0.14fF
C59 a_23_n117# a_45_n115# 0.02fF
C60 a_n4_n115# a_55_n117# 0.02fF
C61 a_43_86# a_74_121# 0.03fF
C62 a_43_336# a_78_336# 0.05fF
C63 a_529_n95# a_609_n95# 0.10fF
C64 a_n4_n115# a_42_n72# 0.14fF
C65 a_23_n117# a_35_n115# 0.95fF
C66 a_18_19# a_48_36# 0.02fF
C67 a_322_n115# a_371_n115# 0.02fF
C68 a_18_336# fin 0.05fF
C69 vdd a_381_n117# 0.13fF
C70 a_349_n117# fout 0.15fF
C71 dn a_48_36# 0.05fF
C72 a_609_n95# a_551_n95# 0.17fF
C73 vdd a_159_n115# 0.18fF
C74 a_159_n115# a_205_n101# 0.16fF
C75 a_186_n117# a_218_n117# 0.57fF
C76 vdd a_66_123# 0.51fF
C77 a_186_n117# a_205_n72# 0.15fF
C78 a_159_n115# a_208_n115# 0.02fF
C79 w_251_224# a_264_214# 0.06fF
C80 vdd a_609_n95# 0.18fF
C81 a_110_121# a_74_227# 0.11fF
C82 a_66_299# a_66_123# 0.15fF
C83 a_23_n117# a_55_n117# 0.57fF
C84 a_n4_n115# a_42_n101# 0.16fF
C85 a_35_n115# a_45_n115# 0.02fF
C86 a_567_n95# cp 0.21fF
C87 a_110_121# m2_160_57# 0.09fF
C88 a_23_n117# a_42_n72# 0.15fF
C89 a_349_n117# a_371_n115# 0.02fF
C90 a_361_n115# fout 0.17fF
C91 a_322_n115# a_381_n117# 0.02fF
C92 a_186_n117# a_205_n101# 0.08fF
C93 vdd a_186_n117# 0.13fF
C94 a_198_n115# a_218_n117# 0.09fF
C95 vdd a_43_86# 0.43fF
C96 a_48_392# up 0.05fF
C97 a_186_n117# a_208_n115# 0.02fF
C98 a_198_n115# a_205_n72# 0.17fF
C99 vdd a_43_336# 0.44fF
C100 a_280_251# a_264_251# 0.13fF
C101 a_45_n115# a_55_n117# 0.07fF
C102 vdd a_102_19# 0.25fF
C103 w_251_224# a_280_214# 0.04fF
C104 a_110_121# a_66_123# 0.01fF
C105 a_35_n115# a_55_n117# 0.09fF
C106 a_42_n72# a_45_n115# 0.08fF
C107 a_23_n117# a_42_n101# 0.08fF
C108 a_43_336# a_66_299# 0.13fF
C109 a_78_336# a_102_336# 0.05fF
C110 a_35_n115# a_42_n72# 0.17fF
C111 a_48_36# a_78_19# 0.03fF
C112 a_349_n117# a_381_n117# 0.57fF
C113 a_361_n115# a_371_n115# 0.02fF
C114 dn a_264_214# 0.12fF
C115 a_205_n72# a_218_n117# 0.12fF
C116 a_198_n115# a_205_n101# 0.16fF
C117 vdd a_198_n115# 0.38fF
C118 vdd a_280_251# 0.04fF
C119 a_567_n95# a_588_n95# 0.07fF
C120 vdd a_368_n101# 0.37fF
C121 a_198_n115# a_208_n115# 0.02fF
C122 vdd a_78_336# 0.25fF
C123 a_280_251# a_289_251# 0.09fF
C124 a_45_n115# a_42_n101# 0.08fF
C125 vdd a_74_121# 0.27fF
C126 a_110_121# a_43_86# 0.71fF
C127 a_35_n115# a_42_n101# 0.16fF
C128 a_42_n72# a_55_n117# 0.12fF
C129 a_588_n95# cp 0.21fF
C130 a_43_336# a_110_121# 0.09fF
C131 a_529_n95# a_551_n95# 0.11fF
C132 fout a_371_n115# 0.08fF
C133 a_361_n115# a_381_n117# 0.09fF
C134 a_218_n117# a_205_n101# 0.22fF
C135 vdd a_218_n117# 0.13fF
C136 dn a_280_214# 0.03fF
C137 a_208_n115# a_218_n117# 0.07fF
C138 a_205_n72# a_205_n101# 0.14fF
C139 vdd a_205_n72# 0.58fF
C140 vdd a_264_251# 0.08fF
C141 w_251_224# a_280_251# 0.15fF
C142 a_368_n101# a_322_n115# 0.16fF
C143 vdd a_529_n95# 0.25fF
C144 a_205_n72# a_208_n115# 0.08fF
C145 vdd a_102_336# 0.25fF
C146 a_55_n117# a_42_n101# 0.22fF
C147 a_529_n95# a_546_n95# 0.10fF
C148 vdd a_551_n95# 0.82fF
C149 a_42_n72# a_42_n101# 0.14fF
C150 a_66_123# a_48_36# 0.10fF
C151 a_102_336# a_66_299# 0.03fF
C152 a_546_n95# a_551_n95# 0.16fF
C153 a_110_121# a_74_121# 0.06fF
C154 fout a_381_n117# 0.12fF
C155 vdd a_205_n101# 0.37fF
C156 a_257_230# a_264_214# 0.08fF
C157 cp a_609_n95# 0.21fF
C158 a_208_n115# a_205_n101# 0.08fF
C159 a_205_n72# a_322_n115# 0.09fF
C160 vdd a_208_n115# 0.13fF
C161 w_251_224# a_264_251# 0.06fF
C162 vdd a_289_251# 0.56fF
C163 a_368_n101# a_349_n117# 0.08fF
C164 vdd a_546_n95# 0.18fF
C165 vdd a_66_299# 0.51fF
C166 a_48_392# a_43_336# 0.16fF
C167 a_42_n72# a_159_n115# 0.09fF
C168 a_43_86# a_48_36# 0.16fF
C169 a_371_n115# a_381_n117# 0.07fF
C170 a_102_19# a_48_36# 0.04fF
C171 vdd w_251_224# 0.36fF
C172 vdd a_322_n115# 0.18fF
C173 cp a_290_206# 0.05fF
C174 a_205_n72# a_349_n117# 0.07fF
C175 w_251_224# a_289_251# 0.13fF
C176 a_368_n101# a_361_n115# 0.16fF
C177 a_48_392# a_78_336# 0.03fF
C178 vdd a_110_121# 1.07fF
C179 vdd a_n4_n115# 0.18fF
C180 vdd fvco_8 0.35fF
C181 a_42_n72# a_186_n117# 0.07fF
C182 a_588_n95# a_609_n95# 0.07fF
C183 a_43_86# a_78_19# 0.05fF
C184 a_66_299# a_110_121# 0.02fF
C185 a_102_19# a_78_19# 0.05fF
C186 vdd a_349_n117# 0.13fF
C187 vdd a_18_336# 0.25fF
C188 a_264_214# a_280_214# 0.13fF
C189 a_368_n101# fout 0.14fF
C190 a_48_392# a_102_336# 0.04fF
C191 a_567_n95# a_529_n95# 0.04fF
C192 vdd a_23_n117# 0.13fF
C193 vdd a_18_19# 0.25fF
C194 up a_280_251# 0.02fF
C195 vdd dn 0.34fF
C196 a_567_n95# a_551_n95# 0.17fF
C197 a_43_336# a_74_227# 0.01fF
C198 a_529_n95# cp 0.14fF
C199 a_n4_n115# fvco_8 0.10fF
C200 m2_160_57# gnd 0.03fF **FLOATING
C201 a_551_n95# gnd 0.09fF
C202 a_609_n95# gnd 0.47fF
C203 a_588_n95# gnd 0.23fF
C204 a_567_n95# gnd 0.39fF
C205 a_546_n95# gnd 0.39fF
C206 a_529_n95# gnd 0.41fF
C207 a_368_n101# gnd 0.85fF
C208 a_381_n117# gnd 0.70fF
C209 a_371_n115# gnd 0.27fF
C210 fout gnd 1.68fF
C211 a_361_n115# gnd 1.06fF
C212 a_349_n117# gnd 0.71fF
C213 a_322_n115# gnd 0.57fF
C214 a_205_n101# gnd 0.85fF
C215 a_218_n117# gnd 0.70fF
C216 a_208_n115# gnd 0.27fF
C217 a_205_n72# gnd 1.82fF
C218 a_198_n115# gnd 1.06fF
C219 a_186_n117# gnd 0.71fF
C220 a_159_n115# gnd 0.57fF
C221 a_42_n101# gnd 0.85fF
C222 a_55_n117# gnd 0.70fF
C223 a_45_n115# gnd 0.27fF
C224 a_42_n72# gnd 1.82fF
C225 a_35_n115# gnd 1.06fF
C226 a_23_n117# gnd 0.71fF
C227 a_n4_n115# gnd 0.57fF
C228 a_102_19# gnd 0.73fF
C229 a_78_19# gnd 0.78fF
C230 a_48_36# gnd 1.59fF
C231 a_18_19# gnd 0.83fF
C232 fvco_8 gnd 2.17fF
C233 a_74_121# gnd 0.80fF
C234 a_290_206# gnd 0.23fF
C235 a_280_214# gnd 0.27fF
C236 a_264_214# gnd 0.22fF
C237 cp gnd 4.86fF
C238 dn gnd 1.24fF
C239 a_289_251# gnd 0.08fF
C240 a_264_251# gnd 0.15fF
C241 a_280_251# gnd 0.26fF
C242 a_43_86# gnd 1.99fF
C243 a_66_123# gnd 1.82fF
C244 a_74_227# gnd 0.80fF
C245 up gnd 1.05fF
C246 a_110_121# gnd 2.65fF
C247 a_66_299# gnd 1.69fF
C248 a_102_336# gnd 0.73fF
C249 a_78_336# gnd 0.78fF
C250 a_43_336# gnd 1.80fF
C251 fin gnd 0.51fF
C252 a_48_392# gnd 1.59fF
C253 a_18_336# gnd 0.83fF
C254 w_251_224# gnd 3.65fF
C255 vdd gnd 41.83fF

****************************
C1 cp 0 25p
C2 N003 0 55p
R1 cp N003 500

********************************

V1 fin 0 PULSE 0 1.8 1n 60p 60p 100n 200n
V2 vdd gnd 1.8

********************************

.tran .1n 10u uic
*.tran .1n 25u 24.5u uic
*.ic V(vin_vco) = 0
.control
run
plot V(fin)+8 V(fvco_8)+8 V(up)+6 V(dn)+4 V(cp)+2 V(fout)
plot V(up)+4 V(dn)+2 V(fin) V(fvco_8)
plot V(up)+4 V(dn)+2 V(fin) V(fout)
plot V(cp)

*plot V(N002)
*plot V(Vin_vco)
*plot V(f_out)
.endc
.end
